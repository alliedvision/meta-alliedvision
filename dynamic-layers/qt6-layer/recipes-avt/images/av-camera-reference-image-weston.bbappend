
CORE_IMAGE_BASE_INSTALL += "v4l2viewer"

TOOLCHAIN_HOST_TASK:append = " nativesdk-packagegroup-qt6-toolchain-host "